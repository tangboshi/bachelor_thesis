<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>carrier_sensing</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>gnuradio.filter.firdes.band_pass(1.0, samp_freq, low_cutoff_freq, high_cutoff_freq, transition_width)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>high_cutoff_freq</value></param>
<param><key>label</key><value>High Cutoff Frequency</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>incoming_signal</value></param>
<param><key>label</key><value>inc_signal</value></param>
<param><key>type</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>low_cutoff_freq</value></param>
<param><key>label</key><value>Low Cutoff Frequency</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>power_level</value></param>
<param><key>type</key><value></value></param>
<param><key>label</key><value>power_level</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_freq</value></param>
<param><key>label</key><value>Sampling Frequency</value></param>
<param><key>value</key><value>40000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>transition_width</value></param>
<param><key>label</key><value>Transition Width</value></param>
<param><key>value</key><value>300</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>power_level</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>incoming_signal</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
