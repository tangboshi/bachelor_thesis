<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>MAC</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_byte_size</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>carrier_sense</value></param>
<param><key>label</key><value>carrier_sense</value></param>
<param><key>type</key><value></value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value></value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value></value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>tx_permission</value></param>
<param><key>type</key><value></value></param>
<param><key>label</key><value>out</value></param>
</block>
<connection><source_block_id>carrier_sense</source_block_id><sink_block_id>tx_permission</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
